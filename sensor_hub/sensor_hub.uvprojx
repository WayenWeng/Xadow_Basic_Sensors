# Keil uVision project sensor_hub.uvprojx, settings and files
target STM32F030 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: sensor_hub +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F051,USE_STM320518_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --C99
  c include: .\User;..\..\..\stm32f0\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\stm32f0\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\stm32f0\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\STM32F0xx_CPAL_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ./User/: main.c stm32f0xx_it.c i2csw.c delay.c adxl345.c sensor_stream.c lm75a.c tls2561t.c i2chw.c
  group Driver
    ../../../stm32f0/STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group ::Device
    RTE/Device/STM32F030F4/: startup_stm32f030.s system_stm32f0xx.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.5.0
